# Keil uVision project demo.uvproj, settings and files
target F4_st7920_u8glib_new (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40XX
  c include: ..\user;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\u8glib\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group SRC
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../user/: main.c u8g_arm.c
  group u8glib
    ../u8glib/src/: u8g_virtual_screen.c chessengine.c u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_arduino_attiny85_hw_spi.c u8g_com_arduino_common.c u8g_com_arduino_fast_parallel.c u8g_com_arduino_hw_spi.c u8g_com_arduino_hw_usart_spi.c u8g_com_arduino_no_en_parallel.c u8g_com_arduino_parallel.c u8g_com_arduino_port_d_wr.c u8g_com_arduino_ssd_i2c.c u8g_com_arduino_st7920_custom.c u8g_com_arduino_st7920_hw_spi.c u8g_com_arduino_st7920_spi.c u8g_com_arduino_std_sw_spi.c u8g_com_arduino_sw_spi.c u8g_com_arduino_t6963.c u8g_com_atmega_hw_spi.c u8g_com_atmega_parallel.c u8g_com_atmega_st7920_hw_spi.c u8g_com_atmega_st7920_spi.c u8g_com_atmega_sw_spi.c u8g_com_i2c.c u8g_com_io.c u8g_com_null.c u8g_cursor.c u8g_delay.c u8g_dev_a2_micro_printer.c u8g_dev_flipdisc_2x7.c u8g_dev_gprof.c u8g_dev_ht1632.c u8g_dev_ili9325d_320x240.c u8g_dev_ks0108_128x64.c u8g_dev_lc7981_160x80.c u8g_dev_lc7981_240x64.c u8g_dev_lc7981_240x128.c u8g_dev_lc7981_320x64.c u8g_dev_null.c u8g_dev_pcd8544_84x48.c u8g_dev_pcf8812_96x65.c u8g_dev_sbn1661_122x32.c u8g_dev_ssd1306_128x32.c u8g_dev_ssd1306_128x64.c u8g_dev_ssd1309_128x64.c u8g_dev_ssd1322_nhd31oled_bw.c u8g_dev_ssd1322_nhd31oled_gr.c u8g_dev_ssd1325_nhd27oled_bw.c u8g_dev_ssd1325_nhd27oled_bw_new.c u8g_dev_ssd1325_nhd27oled_gr.c u8g_dev_ssd1325_nhd27oled_gr_new.c u8g_dev_ssd1327_96x96_gr.c u8g_dev_ssd1351_128x128.c u8g_dev_st7565_64128n.c u8g_dev_st7565_dogm128.c u8g_dev_st7565_dogm132.c u8g_dev_st7565_lm6059.c u8g_dev_st7565_lm6063.c u8g_dev_st7565_nhd_c12832.c u8g_dev_st7565_nhd_c12864.c u8g_dev_st7687_c144mvgd.c u8g_dev_st7920_128x64.c u8g_dev_st7920_192x32.c u8g_dev_st7920_202x32.c u8g_dev_t6963_128x64.c u8g_dev_t6963_240x64.c u8g_dev_t6963_240x128.c u8g_dev_tls8204_84x48.c u8g_dev_uc1601_c128032.c u8g_dev_uc1610_dogxl160.c u8g_dev_uc1701_dogs102.c u8g_dev_uc1701_mini12864.c u8g_ellipse.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pbxh16.c u8g_pbxh24.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u8toa.c u8g_u16toa.c u8g_font.c u8g_font_data.c

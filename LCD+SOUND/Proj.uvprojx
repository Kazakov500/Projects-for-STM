# Keil uVision project Proj.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proj
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\CMSIS\Device\ST\STM32F4xx\Source;.\CMSIS\Device\ST\STM32F4xx\Include;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;D:\Program\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.11.0\Drivers\CMSIS\Include;.\STM32F4xx_StdPeriph_Driver;.\LCD;..\NewLCDFuckinPrj;.\STM32F4_Delay\config;.\STM32F4_Delay\inc;.\STM32F4_Delay\src;D:\Program\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.11.0\Middlewares\ST\STM32_Audio\Addons\PDM;..\NewLCDFuckinPrj2;.\User;.\SOUND_LIBS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c
    ./: SYM.h Table.h
  group StdPereph
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group LCD
    ./LCD/: lcd.c
  group Delay
    ./STM32F4_Delay/src/: Delay.c
  group SOUND_LIBS
    ./SOUND_LIBS/: audio_sample.c stm32f4_discovery.c stm32f4_discovery_audio_codec.c waverecorder.c libPDMFilter_Keil.lib
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
